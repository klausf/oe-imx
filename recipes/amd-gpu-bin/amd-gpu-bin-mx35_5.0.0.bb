require amd-gpu-bin.inc

COMPATIBLE_MACHINE = "mx35pdk"
PACKAGE_ARCH = "${MACHINE_ARCH}"

