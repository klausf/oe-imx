require amd-gpu-bin.inc

COMPATIBLE_MACHINE = "babbage"
PACKAGE_ARCH = "${MACHINE_ARCH}"

